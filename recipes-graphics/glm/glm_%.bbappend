# This is a header-only library, so the main package will be empty.
ALLOW_EMPTY_${PN} = "1"
